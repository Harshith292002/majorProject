options:
  parameters:
    author: VE3PKC
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: RTL-SDR Marine Scanner
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: python_mod.sweeper(fun_prob1)
  states: {}
- name: fun_prob1
  id: variable_function_probe
  parameters:
    block_id: probSign1
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: '5000'
    quad_rate: '480000'
    tau: '0.000075'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.15'
    init: '0'
    low: '0.1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7500'
    decim: '12'
    gain: '1'
    samp_rate: '2400000'
    type: fir_filter_ccf
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Sweeper module
  states: {}
- name: note_1
  id: note
  parameters:
    note: Stop Sweep
  states: {}
- name: probSign1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: python_mod
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\r\nimport sys\r\nf1 = 161000000\r\nf2 = 163000000\r\nf = f1\r\nstep = 25000\r\n\r\ndef sweeper(prob_lvl1) :\r\n    global f\r\n    if (prob_lvl1 == 0):\r\n        f += step\r\n    if f >= f2:\r\n        f=f1\r\n    return f"
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '2400000'
    fc: '500000'
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: '2400000'
    fc: '500000'
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: '161050000'
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: '2400000'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_threshold_ff_0, '0', probSign1, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_1, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
